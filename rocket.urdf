Commit message: Update rocket.urdf

File: rocket.urdf (robot description, URDF)
Before this commit: robot rocket, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=3.0 radius=0.7; visual mesh filename=rocket.obj
